# Keil uVision project infantry.uvprojx, settings and files
target infantry (6150000::V6.15::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CLANG_ARM,ARM_MATH_CM4 ARM_MATH,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Chariot;../User/Device;../User/Interaction;../User/Middleware/Algorithm;../User/Middleware/Driver;../User/Task;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Src;../Middlewares/ST/ARM/DSP/Inc;../Drivers/CMSIS/DSP/Include;../User/Congfig
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Chariot
    ../User/Chariot/: crt_booster.cpp crt_chassis.cpp crt_gimbal.cpp
  group Device
    ../User/Device/: dvc_imu.cpp dvc_boardc_bmi088.cpp dvc_boardc_ist8310.cpp dvc_djimotor.cpp dvc_dmmotor.cpp dvc_lkmotor.cpp dvc_dr16.cpp dvc_supercap.cpp dvc_manifold.cpp dvc_minipc.cpp dvc_referee.cpp dvc_sampler.cpp dvc_serialplot.cpp dvc_servo.cpp dvc_witahrs.cpp dvc_dwt.cpp CharSendTask.cpp dvc_GraphicsSendTask.cpp GraphicsSendTask.cpp
    D:/github/RMUC-2025/User/Device/: dvc_VT13.cpp dvc_VT13.h
  group Interaction
    ../User/Interaction/: ita_chariot.cpp
  group Middleware/Algorithm
    ../User/Middleware/Algorithm/: alg_filter.cpp alg_fsm.cpp alg_pid.cpp alg_slope.cpp user_lib.cpp QuaternionEKF.cpp kalman_filter.cpp PID.cpp alg_MahonyAHRS.cpp alg_power_limit.cpp
  group Middleware/Driver
    ../User/Middleware/Driver/: drv_math.cpp drv_adc.cpp drv_bsp-boarda.cpp drv_can.cpp drv_dwt.cpp drv_i2c.cpp drv_spi.cpp drv_tim.cpp drv_uart.cpp drv_usb.cpp
  group Task
    ../User/Task/: tsk_config_and_callback.cpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Config
    ../User/Congfig/: config.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.0.1
